# Keil uVision project proj_hc32.uvprojx, settings and files
target debug (6160000::V6.16::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj_hc32 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HC32F460,USE_DDL_DRIVER,ARDUINO = 111, __DEBUG
  c include: ..\..\App\inc;..\CMSIS\Include;..\CMSIS\Device\HDSC\hc32f4xx\Include;..\Config;..\Core\inc;..\HAL;..\Driver\inc;..\..\Arduino;..\..\Arduino\Core\avr;..\..\Arduino\Core\variants\hc32f460xx;..\..\Libraries;..\..\Libraries\Adafruit-GFX-Library;..\..\Libraries\Adafruit_BusIO;..\..\Libraries\Adafruit-ST7735-Library;..\..\Libraries\lvgl;..\..\Libraries\lvgl\porting
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\linker\HC32F460xE.sct
  group App
    ../../App/src/: main.cpp
  group Platform/CMSIS
    ../CMSIS/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../CMSIS/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
  group Platform/Core
    ../Core/src/: delay.c dwt.c usart.c addon_gpio.c hc32f4xx_it.c Syscalls_KEIL.c SPI.cpp
  group Platform/Hal
    ../HAL/: HAL.c HAL_CORTEX.c
  group Platform/Drivers
    ../Driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group Platform/Config
    ../Config/: hc32f4xx_conf.h mcu_config.h
  group Arduino
    ../../Arduino/: itoa.c yield.c Print.cpp Stream.cpp WMath.cpp WString.cpp wiring_digital.cpp
    ../../Arduino/Core/avr/: dtostrf.c
    ../../Arduino/Core/variants/hc32f460xx/: variant.cpp
  group Libraries
    ../../Libraries/Adafruit-GFX-Library/: glcdfont.c Adafruit_GFX.cpp Adafruit_SPITFT.cpp
    ../../Libraries/Adafruit-ST7735-Library/: Adafruit_ST77xx.cpp Adafruit_ST7789.cpp
    ../../Libraries/Adafruit_BusIO/: Adafruit_SPIDevice.cpp
  group lvgl
    ../../Libraries/lvgl/src/: lv_init.c
    ../../Libraries/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../Libraries/lvgl/src/display/: lv_display.c
    ../../Libraries/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../Libraries/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../Libraries/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Libraries/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../Libraries/lvgl/src/layouts/: lv_layout.c
    ../../Libraries/lvgl/src/layouts/flex/: lv_flex.c
    ../../Libraries/lvgl/src/layouts/grid/: lv_grid.c
    ../../Libraries/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Libraries/lvgl/src/osal/: lv_os_none.c lv_os.c
    ../../Libraries/lvgl/src/stdlib/: lv_mem.c
    ../../Libraries/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Libraries/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../Libraries/lvgl/src/themes/: lv_theme.c
    ../../Libraries/lvgl/src/themes/default/: lv_theme_default.c
    ../../Libraries/lvgl/src/tick/: lv_tick.c
    ../../Libraries/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Libraries/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Libraries/lvgl/src/widgets/arc/: lv_arc.c
    ../../Libraries/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../Libraries/lvgl/src/widgets/bar/: lv_bar.c
    ../../Libraries/lvgl/src/widgets/button/: lv_button.c
    ../../Libraries/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Libraries/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Libraries/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Libraries/lvgl/src/widgets/chart/: lv_chart.c
    ../../Libraries/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Libraries/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Libraries/lvgl/src/widgets/image/: lv_image.c
    ../../Libraries/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Libraries/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Libraries/lvgl/src/widgets/label/: lv_label.c
    ../../Libraries/lvgl/src/widgets/led/: lv_led.c
    ../../Libraries/lvgl/src/widgets/line/: lv_line.c
    ../../Libraries/lvgl/src/widgets/list/: lv_list.c
    ../../Libraries/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Libraries/lvgl/src/widgets/menu/: lv_menu.c
    ../../Libraries/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Libraries/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Libraries/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../Libraries/lvgl/src/widgets/roller/: lv_roller.c
    ../../Libraries/lvgl/src/widgets/scale/: lv_scale.c
    ../../Libraries/lvgl/src/widgets/slider/: lv_slider.c
    ../../Libraries/lvgl/src/widgets/span/: lv_span.c
    ../../Libraries/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Libraries/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Libraries/lvgl/src/widgets/switch/: lv_switch.c
    ../../Libraries/lvgl/src/widgets/table/: lv_table.c
    ../../Libraries/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Libraries/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Libraries/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Libraries/lvgl/src/widgets/win/: lv_win.c
    ../../Libraries/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Libraries/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../Libraries/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../Libraries/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../Libraries/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../Libraries/lvgl/src/others/observer/: lv_observer.c
  group lvgl/libs
    ../../Libraries/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group lvgl/config
    ../../Libraries/lvgl/: lv_conf.h
  group lvgl/porting
    ../../Libraries/lvgl/porting/: lv_port.cpp lv_port_disp.cpp
